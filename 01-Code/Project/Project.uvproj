# Keil uVision project Project.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Libraries
  group FWLIB
    ../Libraries/: STARTUP.A51 stc89cxx.c stc89cxx.h
  group USER
    ../User/: main.c
    ../User/car/: bsp_car.c bsp_car.h
    ../User/uart/: bsp_uart.c bsp_uart.h
    ../User/tcrt5000/: bsp_tcrt5000.c bsp_tcrt5000.h
    ../User/obstacle_avoidance/: bsp_obstacle_avoidance.c bsp_obstacle_avoidance.h
